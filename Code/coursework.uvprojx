# Keil uVision project coursework.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x20010000,0x0003C000) IROM(0x08000000,0x00100000) IROM2(0x00200000,0x00100000) XRAM(0x2004C000,0x00004000) XRAM2(0x40024000,0x00001000) XRAM3(0x00000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: coursework
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT6: ROM 0x2004c000 size 0x4000
  memory RVCT7: ROM 0x40024000 size 0x1000
  memory RVCT8: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x3c000
  group Source Group 1
    ./: watersensor.c relay.c Buzzer.c GLCD.c main.c led.c button.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Board Support:Drivers:Basic I/O 1.1.1, Board Support:Drivers:SDRAM 1.1.1, Board Support:Drivers:Touch Screen 1.1.1, Board Support:Graphic LCD 1.1.1, Board Support:Touchscreen 1.1.1, Device:STM32Cube Framework:Classic 1.2.5, Device:STM32Cube HAL:ADC 1.2.5, Device:STM32Cube HAL:Common 1.2.5, Device:STM32Cube HAL:Cortex 1.2.5, Device:STM32Cube HAL:DMA 1.2.5, Device:STM32Cube HAL:GPIO 1.2.5, Device:STM32Cube HAL:I2C 1.2.5, Device:STM32Cube HAL:LTDC 1.2.5, Device:STM32Cube HAL:PWR 1.2.5, Device:STM32Cube HAL:RCC 1.2.5, Device:STM32Cube HAL:SDRAM 1.2.5, Device:STM32Cube HAL:UART 1.2.5, Device:Startup 1.2.2
